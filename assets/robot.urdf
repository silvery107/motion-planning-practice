Commit message: disable specular color

File: assets/robot.urdf (robot description, URDF)
Before this commit: robot hovercraft, 7 links, 6 joints
Links:
- link head: geometry collision cylinder length=0.15 radius=0.15; visual cylinder length=0.148 radius=0.15
